# Repository esynr3z/nixie-ps

File README.md:

# Nixie power supply

## Features

High voltage flyback converter for nixie tubes

* Input voltage: 5V - 12V
* Output voltage: 150V - 200V
* Output power: 180V 20mA @ 5V in, 180V 40mA @ 12V in

## Board

Schematic and pcb layout created in KiCad 6 Nightly Build (compatible with KiCad 5). Converter also have been simulated with LTspice XVII.

[Order board v1.0 from OSH Park](https://oshpark.com/shared_projects/xFiD4IsX)

## Testing

### 5V input

Drain and gate oscillograms:

Measured characteristics:

| Vin, V | Iin, mA | Pin, W |  Rload, kOhm | Vout, V | Iout, mA | Pout, W | Eff, % |
|-------:|--------:|-------:|-------------:|--------:|---------:|--------:|-------:|
|   5,34 |     82  |   0,44 |           NC |   180,7 |        - |       - |      - |
|   5,21 |    278  |   1,45 |         37,6 |   180,4 |      4,6 |    0,83 |  57,29 |
|   5,16 |    374  |   1,93 |         28,2 |   180,2 |      6,3 |    1,14 |  58,83 |
|   5,07 |    549  |   2,78 |         18,8 |   180,0 |      9,5 |    1,71 |  61,43 |
|   4,92 |    730  |   3,59 |         14,1 |   179,9 |     12,7 |    2,28 |  63,61 |
|   4,61 |   1170  |   5,39 |          9,4 |   179,5 |     19,2 |    3,45 |  63,90 |

### 12V input

Drain and gate oscillograms:

Measured characteristics:

| Vin, V | Iin, mA | Pin, W |  Rload, kOhm | Vout, V | Iout, mA | Pout, W | Eff, % |
|-------:|--------:|-------:|-------------:|--------:|---------:|--------:|-------:|
|  12,52 |      17 |   0,21 |           NC |   180,4 |        - |       - |      - |
|  12,39 |     195 |   2,42 |         37,6 |   177,9 |      4,4 |    0,78 |  32,40 |
|  12,38 |     217 |   2,69 |         28,2 |   177,8 |      6,0 |    1,07 |  39,71 |
|  12,36 |     249 |   3,08 |         18,8 |   177,6 |      9,2 |    1,63 |  53,09 |
|  12,32 |     273 |   3,36 |         14,1 |   177,6 |     12,3 |    2,18 |  64,95 |
|  12,28 |     326 |   4,00 |          9,4 |   177,9 |     18,9 |    3,36 |  83,99 |
|  12,00 |     789 |   9,47 |          4,7 |   176,7 |     38,1 |    6,73 |  71,11 |

## Notes

* Output current limit can configured with R5 resistor. Less value - more current, but also more heating. With values <0.025 ohm converter may become unstable.
* D1 diode should be replaced with bigger one for operating with maximum current at 12V. Current SOD-123FL diode can be easily thermal destroyed in this mode.

## To do ...

* Improve mosfet layout for better heat dissipation
* Replace one shunt resistor (this values are rare) with 2-3 more generic nominals connected in parallel
* Add test points for drain and gate nets for debugging purpose
* More current, less temperature, more effeciency and etc.

## KiCad design nixie-ps.kicad_pcb

Parts:
C1: 100u; CP_Elec_6.3x5.4
C2: 0.47u; 1812; Rating 250V X7R
C3: 22n; 0805
C4: 0.01u; 0805
D1: E1G; SOD-123FL
D2: SMBJ70CA; SMB
J1, J2: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
Q1: IRFH7185TRPBF; PQFN_5X6MM
R1: 1.2M; 0805
R2: 7.5k; 0805
R3: 4.7k; 0805
R4: 47k; 0805
R5: 0.033; 2010
RV1: PVZ3A152; Murata_PVZ3A; Rating 1.5k
T1: EFD15_2WI; EFD15_B66414W1008D001
U1: LM3488MM; VSSOP-8_3.0x3.0mm_P0.65mm

Connections:
/COMP: C3.1, U1.2 (COMP)
/DR: Q1.4 (G), U1.6 (DR)
/FA: R4.1, U1.7 (FA/SYNC/SD)
/FB: R1.2, R2.1, U1.3 (FB)
/ISEN: C4.1, D2.2, Q1.1 (S), Q1.2 (S), Q1.3 (S), R5.1, U1.1 (ISEN)
/VIN: C1.1, J1.1, J1.2, T1.1 (AA), U1.8 (VIN)
/VOUT: C2.1, D1.1 (K), J2.1, J2.2, R1.1
GND: C1.2, C2.2, C4.2, J1.3, J1.4, J2.3, J2.4, R3.2, R4.2, R5.2, RV1.2, RV1.3, T1.5 (SA), U1.4 (AGND), U1.5 (PGND)
unnamed: C3.2, R3.1
unnamed: D1.2 (A), T1.8 (SB)
unnamed: D2.1, Q1.5 (D), Q1.6 (D), Q1.7 (D), Q1.8 (D), T1.4 (AB)
unnamed: R2.2, RV1.1

Notes on the sheet:
5-12V in
180V 20mA @ 5V in 180V 40mA @ 12V in
R5 note: this value can be in 0.025 - 0.1 ohm range depending on the desired output current and thermal characteristics
Prim 10x0.7 Sec 145x0.2

Board: 2 copper layers, 46.0 x 23.0 mm, 17 parts (7 on the bottom side), 12 nets.

File doc/nixie-ps_bom_A.csv:

Component,Description,Part,References,Value,Footprint,Quantity Per PCB,Datasheet,Rating,Notes
1,,Device_C,C4,0.01u,0805,1,~,,
2,,Device_C,C2,0.47u,1812,1,~,250V X7R,
3,,Device_CP1,C1,100u,CP_Elec_6.3x5.4,1,~,,
4,,Device_C,C3,22n,0805,1,~,,
5,,esynr3z_DiodeRectifier_E1G,D1,E1G,SOD-123FL,1,http://www.lrc.cn/data/pdf/SODE1J-SH.pdf,,
6,,esynr3z_DiodeTVS_SMBJ70CA,D2,SMBJ70CA,SMB,1,http://www.littelfuse.com/~/media/electronics/datasheets/tvs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,,
7,,Connector_Conn_01x04_Male,J1 J2,Conn_01x04_Male,PinHeader_1x04_P2.54mm_Vertical,2,~,,
8,,esynr3z_TransistorFET_IRFH7185TRPBF,Q1,IRFH7185TRPBF,PQFN_5X6MM,1,https://www.infineon.com/dgdl/irfh7185pbf.pdf?fileId=5546d46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,,
9,,Device_R,R5,0.033,2010,1,~,,
10,,Device_R,R1,1.2M,0805,1,~,,
11,,Device_R,R3,4.7k,0805,1,~,,
12,,Device_R,R4,47k,0805,1,~,,
13,,Device_R,R2,7.5k,0805,1,~,,
14,,esynr3z_Potentiometer_PVZ3A,RV1,PVZ3A152,Murata_PVZ3A,1,~,1.5k,
15,,esynr3z_Transformer_EFD15_2WI,T1,EFD15_2WI,EFD15_B66414W1008D001,1,https://en.tdk.eu/inf/80/db/fer/efd_15_8_5.pdf,,"Windings: primary 10 turns x 0.7 mm, secondary 145 turns x 0.2 mm; Core: B66413U0100K187; Coil former: B66414W1008D001; Yokes: B66414B2000;"
16,,esynr3z_RegulatorSwitching_LM3488MM,U1,LM3488MM,VSSOP-8_3.0x3.0mm_P0.65mm,1,http://www.ti.com/lit/ds/symlink/lm3488q-q1.pdf,,

Component Groups:,16
Component Count:,17
Fitted Components:,17
Number of PCBs:,1
Total components:,17
Schematic Version:,A
Schematic Date:,
BoM Date:,Tue 25 Sep 2018 21:00:42 MSK
Schematic Source:,/home/esynr3z/MyRepos/nixie-ps/nixie-ps.sch
KiCad Version:,Eeschema 6.0.0-rc1-unknown-r13783-618182dc

## Commit log

2018-07-01 init
2018-07-01 Add readme
2018-07-02 Replace IRFH5106PBF to RFH7185TRPBF Replace resistor Isense footprint to bigger one Also update ltspice scheme with last changes
2018-07-03 Reroute board left side
2018-07-03 Board minor fixes and gerber update
2018-07-03 Fix C3 R3 references position on silk layer
2018-07-03 ????????? ????? board_order ??? ?????? ????????? 488ec9a40053
2018-07-03 Fix embedded link in readme
2018-07-10 Update worksheet
2018-08-04 Update to KiCAD 6.0.0-rc1
2018-08-04 Fix elec cap 3d model
2018-08-04 Make project fully portable
2018-08-10 Replace old hgignore to gitignore
2018-08-13 Prepare sch and pcb for generating docs
2018-08-13 Remove cache lib from index
2018-08-13 Readme fixes
2018-08-13 Add title to sch
2018-08-22 Ltspice: update transformer and snubber
2018-08-23 Check ltspice model at 5v and 12v
2018-08-24 Model minor fixes
2018-08-24 Readme update
2018-08-24 Minor fixes
2018-08-26 Update sch and pcb after latest simulation
2018-08-26 Fix type in readme markdown
2018-09-14 Massive update after debuging and testing
2018-09-21 Add BOM
2018-09-25 Set revision A in all sheets
2018-09-25 Update docs
